# IAR project Project.ewp, settings and files
configuration Sram_proj (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\Driver\include; ..\..\..\..\Libraries\Device\Phoenix\include; ..\..\..\..\User\LL; ..\..\..\..\Libraries\Protocol\Modbus\include; ..\..\..\..\Libraries\Protocol\Modbus\port; ..\..\..\..\Libraries\Protocol; ..\..\..\..\Libraries\CMSIS\Core\Include; ..\..\..\..\Libraries\CMSIS\DSP\Include; ..\..\..\..\Libraries\Driver\include\LL
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Sram_Proj\Project.hex
  postbuild: Sram_Proj\make.bat
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: Sram_Proj\project.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Eflash_proj (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: Eflash_Proj\Project.hex
  postbuild: Eflash_Proj\make.bat
  ILINK.IlinkIcfFile: Eflash_Proj\project.icf
configuration Eflash2Sram (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: EFLASH2SRAM
  OBJCOPY.OOCOutputFile: Eflash2Sram\Project.hex
  postbuild: Eflash2Sram\make.bat
  ILINK.IlinkIcfFile: Eflash2Sram\project.icf
  group drivers
    ../../../../Libraries/Driver/source/LL/: tx_phe_ll_arctan.c tx_phe_ll_can.c tx_phe_ll_cc_rst.c tx_phe_ll_crc.c tx_phe_ll_datadma.c tx_phe_ll_dftrans.c tx_phe_ll_dmac.c tx_phe_ll_eflash.c tx_phe_ll_epwm.c tx_phe_ll_evsys.c tx_phe_ll_fadc.c tx_phe_ll_fft.c tx_phe_ll_fir.c tx_phe_ll_gpio.c tx_phe_ll_hcc.c tx_phe_ll_iic.c tx_phe_ll_iir.c tx_phe_ll_mac.c tx_phe_ll_matrix.c tx_phe_ll_qei.c tx_phe_ll_rms.c tx_phe_ll_saradc.c tx_phe_ll_sincos.c tx_phe_ll_spi.c tx_phe_ll_spwm.c tx_phe_ll_svpwm.c tx_phe_ll_timer.c tx_phe_ll_usart.c tx_phe_ll_wdt.c
  group Protocol/modbus
    ../../../../Libraries/Protocol/Modbus/: mb.c
    ../../../../Libraries/Protocol/Modbus/Trans_mode/: mbascii.c mbcrc.c mbrtu.c mbtcp.c
    ../../../../Libraries/Protocol/Modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../../../../Libraries/Protocol/Modbus/port/: mbportevent.c
  group Protocol/net/phy
    ../../../../Libraries/Protocol/net/phy/: phy.c phy_device.c
  group RVMDK
    ../../../../Libraries/Device/Phoenix/source/: tx_phe_assert.c tx_phe_debug.c tx_phe_itm.c tx_phe_misc.c tx_phe_system.c txf5200.c txf6200.c
    ../../../../Libraries/Device/Phoenix/source/startup/arm/: tx_phe_startup.c
  group User
    ../../../../User/LL/: config.h include.h main.c tx_phe_irq.c user.c
